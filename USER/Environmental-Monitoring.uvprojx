# Keil uVision project Environmental-Monitoring.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Environmental-Monitoring +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\ENVIRONMENT;..\RS485;..\SIM800C;..\WIND_DIRECTION;..\WIND_SPEED;..\LED-SCREEN;..\PARTICULATE_MATTER;..\DEVICE_CONFIG;..\SYSTEM\usart3;..\SYSTEM\calc;..\SYSTEM\timer;..\WIND;..\LED;..\SYSTEM\iwdg;..\SYSTEM\usart2
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c step.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/usart3/: usart3.c
    ../SYSTEM/calc/: calc.c
    ../SYSTEM/timer/: timer.c
    ../SYSTEM/iwdg/: iwdg.c
    ../SYSTEM/usart2/: usart2.c
  group LED_SCREEN
    ../LED-SCREEN/: led_screen.c
  group RS485
    ../RS485/: rs485.c
  group SIM800C
    ../SIM800C/: sim800c.c
  group WIND_SPEED
    ../WIND_SPEED/: wind_speed.c
  group WIND_DIRECTION
    ../WIND_DIRECTION/: wind_direction.c
  group ENVIRONMENT
    ../ENVIRONMENT/: environment.c
  group PARTICULATE_MATTER
    ../PARTICULATE_MATTER/: particulate_matter.c
  group DEVICE_CONFIG
    ../DEVICE_CONFIG/: readme.txt
  group WIND
    ../WIND/: wind.c
  group LED
    ../LED/: led.c
